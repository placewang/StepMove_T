# Keil uVision project GD32Motor12.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: GD32F427VE GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.0.4
  cpu: IRAM(0x20000000,0x030000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: GD32Motor12 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER,GD32F427,__TARGET_FPU_VFP
  c include: .\CMSIS\GD\GD32F4xx\Include;.\GD32F4xx_standard_peripheral\Include;.\CMSIS\GD\GD32F4xx\Source\ARM;.\CMSIS;.\User\In;.\Bsp
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group F4_dev
    ./CMSIS/GD/GD32F4xx/Source/: system_gd32f4xx.c
    ./User/: gd32f4xx_it.c systick.c
    ./CMSIS/GD/GD32F4xx/Source/ARM/: startup_gd32f407_427.s
  group user
    ./User/: main.c queue.c MotorOperation.c MotorStep.c MotorMove.c
  group bsp
    ./Bsp/: Gpio.c uart.c can.c time.c
  group lib
    ./GD32F4xx_standard_peripheral/Source/: gd32f4xx_crc.c gd32f4xx_rtc.c gd32f4xx_gpio.c gd32f4xx_sdio.c gd32f4xx_timer.c gd32f4xx_usart.c gd32f4xx_wwdgt.c gd32f4xx_fwdgt.c gd32f4xx_can.c gd32f4xx_dbg.c gd32f4xx_dci.c gd32f4xx_rcu.c gd32f4xx_misc.c
